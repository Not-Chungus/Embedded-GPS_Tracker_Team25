# Keil uVision project LCDy_UARTx_GPS_x_mainx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCDy_UARTx_GPS_x_mainx
  AfterMake: fromelf.exe --bin LCDy_UARTx_GPS_x_mainx.axf --output LCDy_UARTx_GPS_x_mainx.bin
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c LCD.c GPIO.c UART.c gps.c gps_coords.c
